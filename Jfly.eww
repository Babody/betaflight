<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM32F411DISCOVERY.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\STM32F411DISCOVERY_bin.ewp</path>
    </project>
    <batchBuild />
</workspace>
