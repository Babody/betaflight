# IAR project STM32F411DISCOVERY.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411VE ST STM32F411VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F411xE; HSE_VALUE=8000000; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT=1; UNALIGNED_SUPPORT_DISABLE; ARM_MATH_CM4; FLASH_SIZE=512; HSE_VALUE=8000000; _GNU_SOURCE; USE_STDPERIPH_DRIVER; STM32F411DISCOVERY; STM32F4; __FORKNAME__="betaflight"; __TARGET__="STM32F411DISCOVERY"; __REVISION__="4778ad6c0"
  ICCARM.CCIncludePath2: src/main; src/main/target; lib/main/STM32F4/Drivers/STM32F4xx_StdPeriph_Driver/inc; lib/main/STM32_USB_OTG_Driver/inc; lib/main/STM32_USB_Device_Library/Core/inc; lib/main/STM32_USB_Device_Library/Class/cdc/inc; lib/main/STM32_USB_Device_Library/Class/hid/inc; lib/main/STM32_USB_Device_Library/Class/hid_cdc_wrapper/inc; lib/main/STM32_USB_Device_Library/Class/msc/inc; lib/main/STM32_USB-FS-Device_Driver/inc; lib/main/CMSIS/Core/Include; lib/main/STM32F4/Drivers/CMSIS/Device/ST/STM32F4xx; src/main/vcpf4; lib/main/FatFS; lib/main/MAVLink; src/main/target/STM32F411DISCOVERY; lib/main/CMSIS/DSP/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F411DISCOVERY.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group lib/mavlink
    lib/main/MAVLink/: checksum.h mavlink_conversions.h mavlink_helpers.h mavlink_types.h protocol.h
    lib/main/MAVLink/common/: common.h mavlink.h mavlink_msg_actuator_control_target.h mavlink_msg_att_pos_mocap.h mavlink_msg_attitude.h mavlink_msg_attitude_quaternion.h mavlink_msg_attitude_quaternion_cov.h mavlink_msg_attitude_target.h mavlink_msg_auth_key.h mavlink_msg_autopilot_version.h mavlink_msg_battery_status.h mavlink_msg_camera_trigger.h mavlink_msg_change_operator_control.h mavlink_msg_change_operator_control_ack.h mavlink_msg_command_ack.h mavlink_msg_command_int.h mavlink_msg_command_long.h mavlink_msg_data_stream.h mavlink_msg_data_transmission_handshake.h mavlink_msg_debug.h mavlink_msg_debug_vect.h mavlink_msg_distance_sensor.h mavlink_msg_encapsulated_data.h mavlink_msg_file_transfer_protocol.h mavlink_msg_global_position_int.h mavlink_msg_global_position_int_cov.h mavlink_msg_global_vision_position_estimate.h mavlink_msg_gps2_raw.h mavlink_msg_gps2_rtk.h mavlink_msg_gps_global_origin.h mavlink_msg_gps_inject_data.h mavlink_msg_gps_raw_int.h mavlink_msg_gps_rtk.h mavlink_msg_gps_status.h mavlink_msg_heartbeat.h mavlink_msg_highres_imu.h mavlink_msg_hil_controls.h mavlink_msg_hil_gps.h mavlink_msg_hil_optical_flow.h mavlink_msg_hil_rc_inputs_raw.h mavlink_msg_hil_sensor.h mavlink_msg_hil_state.h mavlink_msg_hil_state_quaternion.h mavlink_msg_local_position_ned.h mavlink_msg_local_position_ned_cov.h mavlink_msg_local_position_ned_system_global_offset.h mavlink_msg_log_data.h mavlink_msg_log_entry.h mavlink_msg_log_erase.h mavlink_msg_log_request_data.h mavlink_msg_log_request_end.h mavlink_msg_log_request_list.h mavlink_msg_manual_control.h mavlink_msg_manual_setpoint.h mavlink_msg_memory_vect.h mavlink_msg_mission_ack.h mavlink_msg_mission_clear_all.h mavlink_msg_mission_count.h mavlink_msg_mission_current.h mavlink_msg_mission_item.h mavlink_msg_mission_item_int.h mavlink_msg_mission_item_reached.h mavlink_msg_mission_request.h mavlink_msg_mission_request_list.h mavlink_msg_mission_request_partial_list.h mavlink_msg_mission_set_current.h mavlink_msg_mission_write_partial_list.h mavlink_msg_named_value_float.h mavlink_msg_named_value_int.h mavlink_msg_nav_controller_output.h mavlink_msg_optical_flow.h mavlink_msg_optical_flow_rad.h mavlink_msg_param_map_rc.h mavlink_msg_param_request_list.h mavlink_msg_param_request_read.h mavlink_msg_param_set.h mavlink_msg_param_value.h mavlink_msg_ping.h mavlink_msg_position_target_global_int.h mavlink_msg_position_target_local_ned.h mavlink_msg_power_status.h mavlink_msg_radio_status.h mavlink_msg_raw_imu.h mavlink_msg_raw_pressure.h mavlink_msg_rc_channels.h mavlink_msg_rc_channels_override.h mavlink_msg_rc_channels_raw.h mavlink_msg_rc_channels_scaled.h mavlink_msg_request_data_stream.h mavlink_msg_safety_allowed_area.h mavlink_msg_safety_set_allowed_area.h mavlink_msg_scaled_imu.h mavlink_msg_scaled_imu2.h mavlink_msg_scaled_imu3.h mavlink_msg_scaled_pressure.h mavlink_msg_scaled_pressure2.h mavlink_msg_serial_control.h mavlink_msg_servo_output_raw.h mavlink_msg_set_actuator_control_target.h mavlink_msg_set_attitude_target.h mavlink_msg_set_gps_global_origin.h mavlink_msg_set_mode.h mavlink_msg_set_position_target_global_int.h mavlink_msg_set_position_target_local_ned.h mavlink_msg_sim_state.h mavlink_msg_statustext.h mavlink_msg_sys_status.h mavlink_msg_system_time.h mavlink_msg_terrain_check.h mavlink_msg_terrain_data.h mavlink_msg_terrain_report.h mavlink_msg_terrain_request.h mavlink_msg_timesync.h mavlink_msg_v2_extension.h mavlink_msg_vfr_hud.h mavlink_msg_vicon_position_estimate.h mavlink_msg_vision_position_estimate.h mavlink_msg_vision_speed_estimate.h testsuite.h version.h
  group src
    src/main/: ctype.h main.c platform.h
  group src/blackbox
    src/main/blackbox/: blackbox.c blackbox.h blackbox_encoding.c blackbox_encoding.h blackbox_fielddefs.h blackbox_io.c blackbox_io.h
  group src/build
    src/main/build/: atomic.c atomic.h build_config.c build_config.h debug.c debug.h version.c version.h
  group src/cms
    src/main/cms/: cms.c cms.h cms_menu_blackbox.c cms_menu_blackbox.h cms_menu_builtin.c cms_menu_builtin.h cms_menu_imu.c cms_menu_imu.h cms_menu_ledstrip.c cms_menu_ledstrip.h cms_menu_misc.c cms_menu_misc.h cms_menu_osd.c cms_menu_osd.h cms_menu_power.c cms_menu_power.h cms_menu_vtx_rtc6705.c cms_menu_vtx_rtc6705.h cms_menu_vtx_smartaudio.c cms_menu_vtx_smartaudio.h cms_menu_vtx_tramp.c cms_menu_vtx_tramp.h cms_types.h
  group src/common
    src/main/common/: axis.h bitarray.c bitarray.h color.h colorconversion.c colorconversion.h crc.c crc.h encoding.c encoding.h explog_approx.c filter.c filter.h gps_conversion.c gps_conversion.h huffman.c huffman.h huffman_table.c maths.c maths.h printf.c printf.h streambuf.c streambuf.h string_light.c strtol.c strtol.h time.c time.h typeconversion.c typeconversion.h utils.h
  group src/config
    src/main/config/: config_eeprom.c config_eeprom.h config_reset.h config_streamer.c config_streamer.h config_unittest.h feature.c feature.h
  group src/drivers
    src/main/drivers/: adc.c adc.h adc_impl.h adc_stm32f4xx.c audio.h buf_writer.c buf_writer.h bus.c bus.h bus_i2c.h bus_i2c_busdev.c bus_i2c_busdev.h bus_i2c_config.c bus_i2c_impl.h bus_i2c_soft.c bus_i2c_stm32f10x.c bus_spi.c bus_spi.h bus_spi_config.c bus_spi_impl.h bus_spi_pinconfig.c bus_spi_stdperiph.c buttons.c buttons.h camera_control.c camera_control.h display.c display.h display_ug2864hsweg01.c display_ug2864hsweg01.h dma.h dma_reqmap.c dma_reqmap.h dma_stm32f4xx.c exti.c exti.h flash.c flash.h flash_impl.h flash_m25p16.c flash_m25p16.h flash_w25m.c flash_w25m.h inverter.c inverter.h io.c io.h io_def.h io_def_generated.h io_impl.h io_types.h max7456.c max7456.h max7456_symbols.h mco.c mco.h nvic.h persistent.c persistent.h pinio.c pinio.h pwm_esc_detect.c pwm_esc_detect.h pwm_output.c pwm_output.h pwm_output_counts.h pwm_output_dshot.c rcc.c rcc.h rcc_types.h resource.c resource.h sdcard.c sdcard.h sdcard_impl.h sdcard_sdio_baremetal.c sdcard_spi.c sdcard_standard.c sdcard_standard.h sdio_f4xx.c sdio_f7xx.c sdmmc_sdio.h sensor.h serial.c serial.h serial_pinconfig.c serial_softserial.c serial_softserial.h serial_uart.c serial_uart.h serial_uart_impl.h serial_uart_init.c serial_uart_pinconfig.c serial_uart_stm32f4xx.c serial_usb_vcp.h sound_beeper.c sound_beeper.h stack_check.c stack_check.h stm32f7xx_ll_ex.h system.c system.h system_stm32f4xx.c time.h timer.c timer.h timer_common.c timer_def.h timer_impl.h timer_stm32f4xx.c transponder_ir.h transponder_ir_arcitimer.c transponder_ir_arcitimer.h transponder_ir_erlt.c transponder_ir_erlt.h transponder_ir_ilap.c transponder_ir_ilap.h transponder_ir_io_hal.c transponder_ir_io_stdperiph.c usb_io.c usb_io.h usb_msc.h usb_msc_f4xx.c usb_msc_f7xx.c vtx_common.c vtx_common.h vtx_rtc6705.c vtx_rtc6705.h vtx_rtc6705_soft_spi.c
  group src/drivers/accgyro
    src/main/drivers/accgyro/: accgyro_mpu.c accgyro_mpu.h
  group src/drivers/rx
    src/main/drivers/rx/: rx_a7105.c rx_a7105.h rx_cc2500.c rx_cc2500.h rx_cyrf6936.c rx_cyrf6936.h rx_nrf24l01.c rx_nrf24l01.h rx_pwm.c rx_pwm.h rx_spi.c rx_spi.h rx_xn297.c rx_xn297.h
  group src/fc
    src/main/fc/: board_info.c board_info.h config.c config.h controlrate_profile.c controlrate_profile.h core.c core.h dispatch.c dispatch.h hardfaults.c init.c init.h rc.c rc.h rc_adjustments.c rc_adjustments.h rc_controls.c rc_controls.h rc_modes.c rc_modes.h runtime_config.c runtime_config.h tasks.c tasks.h
  group src/flight
    src/main/flight/: failsafe.c failsafe.h gps_rescue.c gps_rescue.h imu.c imu.h mixer.c mixer.h mixer_tricopter.c mixer_tricopter.h pid.c pid.h position.c position.h servos.c servos.h servos_tricopter.c
  group src/interface
    src/main/sensors/: battery.h
    src/main/interface/: cli.c cli.h crsf_protocol.h d_msp.c msp.h msp_box.c msp_box.h msp_protocol.h settings.c settings.h smartaudio_protocol.c smartaudio_protocol.h tramp_protocol.c tramp_protocol.h
  group src/io
    src/main/io/: beeper.c beeper.h dashboard.c dashboard.h displayport_crsf.c displayport_crsf.h displayport_hott.c displayport_hott.h displayport_max7456.c displayport_max7456.h displayport_msp.c displayport_msp.h displayport_oled.c displayport_oled.h displayport_srxl.c displayport_srxl.h flashfs.c flashfs.h gimbal.h gps.c gps.h ledstrip.c ledstrip.h motors.h osd.c osd.h pidaudio.c pidaudio.h piniobox.c piniobox.h rcdevice.c rcdevice.h rcdevice_cam.c rcdevice_cam.h serial.c serial.h serial_4way.c serial_4way.h serial_4way_avrootloader.c serial_4way_avrootloader.h serial_4way_impl.h serial_4way_stk500v2.c serial_4way_stk500v2.h servos.h spektrum_rssi.c spektrum_rssi.h spektrum_vtx_control.c spektrum_vtx_control.h statusindicator.c statusindicator.h transponder_ir.c transponder_ir.h usb_cdc_hid.c usb_cdc_hid.h usb_msc.c usb_msc.h vtx.c vtx.h vtx_control.c vtx_control.h vtx_rtc6705.c vtx_rtc6705.h vtx_smartaudio.c vtx_smartaudio.h vtx_string.c vtx_string.h vtx_tramp.c vtx_tramp.h
  group src/msc
    src/main/msc/: emfat.c emfat.h emfat_file.c emfat_file.h usbd_msc_desc.c usbd_msc_desc.h usbd_storage.c usbd_storage.h usbd_storage_emfat.c usbd_storage_emfat.h usbd_storage_sd_spi.c usbd_storage_sdio.c
  group src/msp
    src/main/msp/: msp_serial.c msp_serial.h
  group src/pg
    src/main/pg/: adc.h beeper.h beeper_dev.h board.h bus_i2c.h bus_spi.h dashboard.h flash.h gyrodev.h max7456.h mco.h pg.c pg.h pinio.h piniobox.h rcdevice.h rx.h rx_spi.h sdcard.h sdio.h serial_uart.h timerio.h usb.h vcd.h
  group src/rx
    src/main/rx/: cc2500_common.c cc2500_common.h cc2500_frsky_common.h cc2500_frsky_d.c cc2500_frsky_d.h cc2500_frsky_shared.c cc2500_frsky_shared.h cc2500_frsky_x.c cc2500_frsky_x.h cc2500_sfhss.c cc2500_sfhss.h crsf.c crsf.h cyrf6936_spektrum.c cyrf6936_spektrum.h flysky.c flysky.h flysky_defs.h fport.c fport.h ibus.c ibus.h jetiexbus.c jetiexbus.h msp.c msp.h nrf24_cx10.c nrf24_cx10.h nrf24_h8_3d.c nrf24_h8_3d.h nrf24_inav.c nrf24_inav.h nrf24_kn.c nrf24_kn.h nrf24_syma.c nrf24_syma.h nrf24_v202.c nrf24_v202.h pwm.c pwm.h rx.c rx.h rx_spi.c rx_spi.h rx_spi_common.c rx_spi_common.h sbus.c sbus.h sbus_channels.c sbus_channels.h spektrum.c spektrum.h sumd.c sumd.h sumh.c sumh.h targetcustomserial.h xbus.c xbus.h
  group src/scheduler
    src/main/scheduler/: scheduler.c scheduler.h
  group src/sensors
    src/main/sensors/: acceleration.c acceleration.h adcinternal.c adcinternal.h barometer.c barometer.h battery.c boardalignment.c boardalignment.h compass.c compass.h current.c current.h current_ids.h esc_sensor.c esc_sensor.h gyro.c gyro.h gyro_filter_impl.h gyroanalyse.c gyroanalyse.h initialisation.c initialisation.h rangefinder.c rangefinder.h sensors.h voltage.c voltage.h voltage_ids.h
  group src/startup
    src/main/startup/: startup_stm32f411xe.s
  group src/target
    src/main/target/: common_defaults_post.h common_post.h common_pre.h config_helper.c config_helper.h stm32f4xx_hal_conf.h system_stm32f4xx.c system_stm32f4xx.h
    src/main/target/STM32F411DISCOVERY/: target.c target.h
  group src/telemetry
    src/main/telemetry/: crsf.c crsf.h frsky_hub.c frsky_hub.h hott.c hott.h ibus.c ibus.h ibus_shared.c ibus_shared.h jetiexbus.c jetiexbus.h ltm.c ltm.h mavlink.c mavlink.h msp_shared.c msp_shared.h smartport.c smartport.h srxl.c srxl.h telemetry.c telemetry.h
  group src/vcpf4
    src/main/vcpf4/: stm32f4xx_it.c stm32f4xx_it.h usb_bsp.c usb_conf.h usbd_cdc_vcp.c usbd_cdc_vcp.h usbd_conf.h usbd_desc.c usbd_desc.h usbd_usr.c
