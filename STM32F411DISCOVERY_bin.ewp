# IAR project STM32F411DISCOVERY_bin.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411VE ST STM32F411VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    obj/main/: betaflight_STM32F411DISCOVERY.elf
  group gcc
    src/main/startup/: startup_stm32f411xe.s
    src/main/target/link/: stm32_flash_f411.ld stm32_flash_split.ld
  group iar
    ./: Makefile
    iar/: startup_stm32f411xe.s stm32f411xE.icf
  group map
    obj/main/: betaflight_STM32F411DISCOVERY.map
